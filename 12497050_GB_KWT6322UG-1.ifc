Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: c94c2c0e-6b1f-46e7-863e-78adf35f55b8, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-14T23:28:27+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12497050_GB_KWT6322UG-1:36632202_GB_12497050_KWT6322UG-1, (2)
In: Default
Type - Material: Spruce, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel_Black, z_Miele_Design_Glass, z_Miele_Connection_Electric, Polypropylene, z_Miele_Design_Steel_Chrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 822 mm; Depth: 577 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 36632202_GB_12497050_KWT6322UG-1; sets with these values: 2
